# Keil uVision project TLE9893_2QKW62S_ADC1_POTI_SWTRG.uvprojx, settings and files
target TLE9893_2QKW62S (6220000::V6.22::ARMCLANG)
  device: TLE9893_2QKW62S Infineon
  pack: Infineon.TLE988x_9x_DFP.1.2.0
  cpu: IRAM(0x18000000,0x1C00) IRAM2(0x18002000,0x6000) IROM(0x11000000,0x8000) IROM2(0x12002000,0x3E000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TLE9893_2QKW62S_ADC1_POTI_SWTRG
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-unsafe-buffer-usage
  asm misc: --diag_suppress 1609
  library: MicroLIB
  memory RVCT4: ROM 0x11000100 size 0x5f00
  memory RVCT5: ROM 0x12002000 size 0x3e000
  memory RVCT9: RAM 0x18000000 size 0x2000
  memory RVCT10: RAM 0x18002000 size 0x5c00
  scatter file: .\RTE\Device\TLE9893_2QKW62S\tle9883_93.sct
  group app
    ./: Sensor_Functions.c clarke_tranform.c park_transform.c pll_srf.c clarke_transform.h pll_srf.h park_transform.h voltage_loop.c voltage_loop.h pi_controller.c pi_controller.h inverse_park.c inverse_park.h svpwm.c svpwm.h gpio_pwm.h gpio_pwm.c main_control.c main.c Sensor_Functions.h main_control.h
software components: CMSIS:CORE 6.1.0, Device Driver:TLELib:CANCOM 301.0, Device:ConfigWizard 0.0.0, Device:Startup 0.4.0, Device:TLELib:ADC1 0.6.0, Device:TLELib:ADC2 0.5.7, Device:TLELib:BDRV 0.9.0, Device:TLELib:BOOTROM 0.3.3, Device:TLELib:CCU7 0.5.0, Device:TLELib:CSACSC 0.2.8, Device:TLELib:GPIO 0.2.6, Device:TLELib:INT 0.3.1, Device:TLELib:ISR 0.5.1, Device:TLELib:PMU 0.6.0, Device:TLELib:SCU 0.5.5, Device:TLELib:SDADC 0.4.0, Device:TLELib:SSC 0.3.8, Device:TLELib:TIMER2X 0.5.0, Device:TLELib:UART 0.6.1
