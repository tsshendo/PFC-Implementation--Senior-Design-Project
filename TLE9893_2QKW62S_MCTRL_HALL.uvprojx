# Keil uVision project TLE9893_2QKW62S_MCTRL_HALL.uvprojx, settings and files
target TLE9893_2QKW62S (6190000::V6.19::ARMCLANG)
  device: TLE9893_2QKW62S Infineon
  pack: Infineon.TLE988x_9x_DFP.1.2.0
  cpu: IRAM(0x18000000,0x1C00) IRAM2(0x18002000,0x6000) IROM(0x11000000,0x8000) IROM2(0x12002000,0x3E000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TLE9893_2QKW62S_MCTRL_HALL
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-unsafe-buffer-usage
  c include: .\mctrl
  asm misc: --diag_suppress 1609
  memory RVCT4: ROM 0x11000000 size 0x6000
  memory RVCT5: ROM 0x12002000 size 0x3e000
  memory RVCT9: RAM 0x18000000 size 0x2000
  memory RVCT10: RAM 0x18002000 size 0x5c00
  scatter file: .\RTE\Device\TLE9893_2QKW62S\tle9883_93.sct
  group mctrl
    ./mctrl/: bldc_motor_lib.c bldc_motor_lib.h timer_lib.c timer_lib.h
software components: CMSIS:CORE 5.6.0, Device:ConfigWizard 0.0.0, Device:Startup 0.4.0, Device:TLELib:ADC1 0.4.7, Device:TLELib:ADC2 0.5.6, Device:TLELib:BDRV 0.8.1, Device:TLELib:BOOTROM 0.3.1, Device:TLELib:CCU7 0.3.9, Device:TLELib:CSACSC 0.2.7, Device:TLELib:DMA 0.3.1, Device:TLELib:GPIO 0.2.5, Device:TLELib:GPT12 0.6.2, Device:TLELib:INT 0.3.1, Device:TLELib:ISR 0.5.0, Device:TLELib:MON 0.3.4, Device:TLELib:PMU 0.5.6, Device:TLELib:SCU 0.5.4, Device:TLELib:SDADC 0.4.0, Device:TLELib:SSC 0.3.8, Device:TLELib:TIMER2X 0.5.0, Device:TLELib:UART 0.5.9
