# IAR project TLE9893_2QKW62S_MCTRL_HALL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TLE9893-2QKW62S Infineon TLE9893-2QKW62S
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.IExtraOptions: --diag_suppress Pa082
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; mctrl
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: TLE9893_2QKW62S_MCTRL_HALL.srec
  ILINK.IlinkOutputFile: TLE9893_2QKW62S_MCTRL_HALL.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  group app
    app/: main.c
  group mctrl
    mctrl/: bldc_motor_lib.c bldc_motor_lib.h timer_lib.c timer_lib.h
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device ConfigWizard
    RTE/Device/TLE9893_2QKW62S/: adc1.py adc1_defines.h adc2.py adc2_defines.h bdrv_defines.h bsl_defines.h bsl_defines_IAR.inc bsl_defines_inc_save_handler.py cantrx_defines.h ccu7_calc.py ccu7_defines.h config.icwp csacsc_defines.h dma_defines.h gpio_defines.h gpt12_defines.h icw_ocn.xml icw_ocn_adc1.xml icw_ocn_adc2.xml icw_ocn_BDRV.xml icw_ocn_bemf.xml icw_ocn_bsl.xml icw_ocn_cantrx.xml icw_ocn_CCU7.xml icw_ocn_CSACSC.xml icw_ocn_dma.xml icw_ocn_gpio.xml icw_ocn_gpt12.xml icw_ocn_interrupt.xml icw_ocn_mon.xml icw_ocn_pmu.xml icw_ocn_scu.xml icw_ocn_sdadc.xml icw_ocn_SSC.xml icw_ocn_timer2x.xml icw_ocn_UARTx.xml isr_defines.h pmu_defines.h scu.py scu_defines.h sdadc_defines.h ssc_defines.h template_adc1_calibration.xml template_adc1_channel.xml template_adc1_channel_class.xml template_adc1_compare.xml template_adc1_filter.xml template_adc1_sequencer.xml template_adc1_sequencer_slots.xml template_adc1_sequencer_variables.xml template_adc1_variables2.xml template_adc2_channel.xml template_adc2_channel_class.xml template_adc2_channel_user.xml template_adc2_compare.xml template_adc2_compare_fix.xml template_adc2_compare_fix_nmi_lo.xml template_adc2_compare_fix_nmi_up.xml template_adc2_compare_fix_nmi_uplo.xml template_adc2_filter.xml template_adc2_filter_fix.xml template_adc2_sequencer.xml template_adc2_sequencer_slots.xml template_bdrv_currentsConst.xml template_bdrv_currentsSeq.xml template_bdrv_hb_chrg_dischrg_settings.xml template_bdrv_hb_graph.xml template_bdrv_hb_settings.xml template_bdrv_timingsConst.xml template_bdrv_timingsSeq.xml template_ccu7_cmpval_input.xml template_ccu7_deadtime_graph.xml template_ccu7_perval_input.xml template_ccu7_sum_cmpval.xml template_ccu7_sum_t1x.xml template_ccu7_t12.xml template_ccu7_t13.xml template_ccu7_t141516.xml template_dma_mode.xml template_gpio_p0p1.xml template_gpio_p2.xml template_gpt12_mode.xml template_gpt12_timer.xml template_interrupt_overview_adc1.xml template_interrupt_overview_adc2.xml template_interrupt_overview_bemf_sdadc.xml template_interrupt_overview_can.xml template_interrupt_overview_ccu7.xml template_interrupt_overview_dma.xml template_interrupt_overview_extint.xml template_interrupt_overview_gpt12.xml template_interrupt_overview_memctrl.xml template_interrupt_overview_mon.xml template_interrupt_overview_ssc.xml template_interrupt_overview_t20.xml template_interrupt_overview_t21.xml template_interrupt_overview_uart.xml template_interrupt_overview_warn.xml template_pmu_gpiowake.xml template_pmu_interrupt.xml template_pmu_timer.xml template_sdadc_channel.xml template_sdadc_interrupt.xml template_sdadc_timers.xml template_ssc_graph.xml template_ssc_mode.xml template_ssc_pinsel.xml template_ssc_timer.xml template_t2x_graph.xml template_t2x_mode.xml template_uart_graph.xml template_uart_mode.xml timer2x.py timer2x_defines.h tle989x.svd tle989x_64.pin uart.py uart_defines.h
  group CMSIS-Pack/Device Startup
    RTE/Device/TLE9893_2QKW62S/: cmsis_misra.h error_codes.h startup_tle989x.c system_tle989x.c system_tle989x.h TLE9893.icf tle989x.h tle_device.c tle_device.h tle_variants.h types.h
  group CMSIS-Pack/Device.TLELib ADC1
    RTE/Device/TLE9893_2QKW62S/: adc1.c adc1.h
  group CMSIS-Pack/Device.TLELib ADC2
    RTE/Device/TLE9893_2QKW62S/: adc2.c adc2.h
  group CMSIS-Pack/Device.TLELib BDRV
    RTE/Device/TLE9893_2QKW62S/: bdrv.c bdrv.h
  group CMSIS-Pack/Device.TLELib BOOTROM
    RTE/Device/TLE9893_2QKW62S/: bootrom.c bootrom.h
  group CMSIS-Pack/Device.TLELib CCU7
    RTE/Device/TLE9893_2QKW62S/: ccu7.c ccu7.h
  group CMSIS-Pack/Device.TLELib CSACSC
    RTE/Device/TLE9893_2QKW62S/: csacsc.c csacsc.h
  group CMSIS-Pack/Device.TLELib DMA
    RTE/Device/TLE9893_2QKW62S/: dma.c dma.h
  group CMSIS-Pack/Device.TLELib GPIO
    RTE/Device/TLE9893_2QKW62S/: gpio.c gpio.h
  group CMSIS-Pack/Device.TLELib GPT12
    RTE/Device/TLE9893_2QKW62S/: gpt12.c gpt12.h
  group CMSIS-Pack/Device.TLELib INT
    RTE/Device/TLE9893_2QKW62S/: int.c int.h
  group CMSIS-Pack/Device.TLELib ISR
    RTE/Device/TLE9893_2QKW62S/: isr.h isr_exceptions.c isr_nvic_irq0_handler.c isr_nvic_irq10_handler.c isr_nvic_irq11_handler.c isr_nvic_irq12_handler.c isr_nvic_irq13_handler.c isr_nvic_irq14_handler.c isr_nvic_irq15_handler.c isr_nvic_irq16_handler.c isr_nvic_irq17_handler.c isr_nvic_irq18_handler.c isr_nvic_irq19_handler.c isr_nvic_irq1_handler.c isr_nvic_irq20_handler.c isr_nvic_irq21_handler.c isr_nvic_irq22_handler.c isr_nvic_irq23_handler.c isr_nvic_irq24_handler.c isr_nvic_irq25_handler.c isr_nvic_irq26_handler.c isr_nvic_irq27_handler.c isr_nvic_irq28_handler.c isr_nvic_irq29_handler.c isr_nvic_irq2_handler.c isr_nvic_irq30_handler.c isr_nvic_irq31_handler.c isr_nvic_irq3_handler.c isr_nvic_irq4_handler.c isr_nvic_irq5_handler.c isr_nvic_irq7_handler.c isr_nvic_irq8_handler.c isr_nvic_irq9_handler.c
  group CMSIS-Pack/Device.TLELib MON
    RTE/Device/TLE9893_2QKW62S/: mon.c mon.h
  group CMSIS-Pack/Device.TLELib PMU
    RTE/Device/TLE9893_2QKW62S/: pmu.c pmu.h
  group CMSIS-Pack/Device.TLELib SCU
    RTE/Device/TLE9893_2QKW62S/: scu.c scu.h
  group CMSIS-Pack/Device.TLELib SDADC
    RTE/Device/TLE9893_2QKW62S/: sdadc.c sdadc.h
  group CMSIS-Pack/Device.TLELib SSC
    RTE/Device/TLE9893_2QKW62S/: ssc.c ssc.h
  group CMSIS-Pack/Device.TLELib TIMER2X
    RTE/Device/TLE9893_2QKW62S/: timer2x.c timer2x.h
  group CMSIS-Pack/Device.TLELib UART
    RTE/Device/TLE9893_2QKW62S/: uart.c uart.h
